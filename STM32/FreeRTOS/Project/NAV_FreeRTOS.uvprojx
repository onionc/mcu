# Keil uVision project NAV_FreeRTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: NAV_FreeRTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\freertos\Source\Include;..\freertos\Source\protable\RVDS\ARM_CM4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM4\ARMCM4_ac5.sct
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/: list.c task.c FreeRTOS.c projdefs.c
    ../freertos/Source/protable/RVDS/ARM_CM4/: port.c
  group doc
    ../Doc/: readme.md
software components: CMSIS:CORE 5.3.0, Device:Startup 2.0.0
