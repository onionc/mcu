# Keil uVision project A002.I2C_MPU6050.uvprojx, settings and files
target A002.I2C_MPU6050 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: A002.I2C_MPU6050.bin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_DMP,EMPL_TARGET_STM32F4,MPU6050,MPL_LOG_NDEBUG=1,EMPL
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/MPU6050/Inc;..\Drivers\MPU6050\MPL\driver\eMPL;..\Drivers\MPU6050\MPL\driver\include;..\Drivers\MPU6050\MPL\driver\stm32L;..\Drivers\MPU6050\MPL\eMPL-hal;..\Drivers\MPU6050\MPL\mllite;..\Drivers\MPU6050\MPL\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/MPU6050
    ../Drivers/MPU6050/Src/: MPU6050.c
    ../Drivers/MPU6050/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Drivers/MPU6050/MPL/driver/stm32L/: log_stm32.c
    ../Drivers/MPU6050/MPL/eMPL-hal/: eMPL_outputs.c
    ../Drivers/MPU6050/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../Drivers/MPU6050/MPL/mpl/: libmpllib.lib
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
