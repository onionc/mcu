# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\spi;.\w25q128;.\i2c;.\oled;..\
  group src
    ./: STARTUP.A51 main.c
  group spi
    ./spi/: spi.c spi.h
  group w25q128
    ./w25q128/: w25q128.c w25q128.h
  group i2c
    ./i2c/: i2c.c
  group oled
    ./oled/: oled.c
